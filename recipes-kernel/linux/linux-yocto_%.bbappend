FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://i2c-stub.cfg"
